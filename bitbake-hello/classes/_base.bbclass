# should not exist file base.bbclass
